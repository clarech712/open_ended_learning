Commit message: renamed single model

File: gazebo/models/object.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- removed link object
- added link cube, mass 1.0; collision box size=1 1 1; visual box size=1 1 1
